# Remove 'ps' from BusyBox as Greengrass needs the real one
SRC_URI:remove = "file://ps.cfg"
